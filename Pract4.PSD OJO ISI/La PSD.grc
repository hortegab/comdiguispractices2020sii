options:
  parameters:
    author: hortegab
    description: x<x<x
    generate_options: qt_gui
    id: pilas
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ensayos
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: Fmax
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Fresolucion
  id: variable
  parameters:
    value: 2*Fmax/N
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: PSDmax
  id: variable
  parameters:
    value: '6e-2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: E3TRadio_vector_average_hob_0
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: Ensayos
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./samp_rate)
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hortegab/MisGits/comdig_multimedia/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: N
    gui_hint: 2,0,1,1
    name: '"Espetro dinamico"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 1,0,1,1
    label1: '.'
    name: PSD
    showports: 'True'
    vlen: N
    width1: '4'
    x_axis_label: '"Frecuencia"'
    x_start: '-samp_rate/2'
    x_step: (samp_rate-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (Watt/Hz)"'
    y_units: '"Watt/Hz"'
    ymax: PSDmax
    ymin: '0.'
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}

connections:
- [E3TRadio_vector_average_hob_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_squared_0, '0', E3TRadio_vector_average_hob_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_wavfile_source_0, '0', vs_0_2, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [vso_0_1_0_0_0, '0', blocks_float_to_complex_0, '0']
- [vso_0_1_0_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
