options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: Constelacion1
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: Constelacion2
  id: variable
  parameters:
    value: digital.constellation_8psk().points()
  states: {}
- name: Constelacion3
  id: variable
  parameters:
    value: digital.qam_constellation(64).points()
  states: {}
- name: Constelacion4
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: EsN0max
  id: variable
  parameters:
    value: '30.'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '-10.'
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: len(Constelacion3)
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: len(Constelacion4)
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: len(Constelacion2)
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: len(Constelacion1)
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_BERTool_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_1
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_demod_constelacion_cb_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion4
  states: {}
- name: b_demod_constelacion_cb_0_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion3
  states: {}
- name: b_demod_constelacion_cb_0_0_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion1
  states: {}
- name: b_demod_constelacion_cb_0_1
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_mod_constelacion_cb_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion4
  states: {}
- name: b_mod_constelacion_cb_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion3
  states: {}
- name: b_mod_constelacion_cb_0_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_mod_constelacion_cb_0_0_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion1
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: '"QPSK"'
    label2: '"8PSK"'
    label3: '"16QAM"'
    label4: '"BPSK"'
    name: '"Curvas de SER"'
    nconnections: '4'
    showports: 'True'
    vlen: N_snr
    width1: '6'
    width2: '6'
    width3: '6'
    width4: '6'
    x_axis_label: '"Es/N0 [dB]"'
    x_start: EsN0min
    x_step: (EsN0max-EsN0min)/float(N_snr)
    x_units: '"dB"'
    y_axis_label: '"log(Pe)"'
    ymax: '0'
    ymin: '-5'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX3
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX0
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX0
  states: {}
- name: vs0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: vs0_0
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: vs0_0_0
  id: virtual_sink
  parameters:
    stream_id: TX0
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: vs1
  id: virtual_sink
  parameters:
    stream_id: RX3
  states: {}
- name: vs1_0
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX0
  states: {}
- name: vs1_1
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}

connections:
- [analog_random_source_x, '0', b_mod_constelacion_cb_0_0, '0']
- [analog_random_source_x, '0', vs0_0, '0']
- [analog_random_source_x_0, '0', b_mod_constelacion_cb_0, '0']
- [analog_random_source_x_0, '0', vs0, '0']
- [analog_random_source_x_0_0, '0', b_mod_constelacion_cb_0_0_0, '0']
- [analog_random_source_x_0_0, '0', vs0_1, '0']
- [analog_random_source_x_1, '0', b_mod_constelacion_cb_0_0_0_0, '0']
- [analog_random_source_x_1, '0', vs0_0_0, '0']
- [b_BERTool_0, '0', b_demod_constelacion_cb_0, '0']
- [b_BERTool_0, '1', qtgui_vector_sink_f_0, '3']
- [b_BERTool_0_0, '0', b_demod_constelacion_cb_0_0, '0']
- [b_BERTool_0_0, '1', qtgui_vector_sink_f_0, '2']
- [b_BERTool_0_0_0, '0', b_demod_constelacion_cb_0_0_0, '0']
- [b_BERTool_0_0_0, '1', qtgui_vector_sink_f_0, '0']
- [b_BERTool_0_1, '0', b_demod_constelacion_cb_0_1, '0']
- [b_BERTool_0_1, '1', qtgui_vector_sink_f_0, '1']
- [b_demod_constelacion_cb_0, '0', vs1, '0']
- [b_demod_constelacion_cb_0_0, '0', vs1_0, '0']
- [b_demod_constelacion_cb_0_0_0, '0', vs1_0_0, '0']
- [b_demod_constelacion_cb_0_1, '0', vs1_1, '0']
- [b_mod_constelacion_cb_0, '0', b_BERTool_0, '0']
- [b_mod_constelacion_cb_0_0, '0', b_BERTool_0_0, '0']
- [b_mod_constelacion_cb_0_0_0, '0', b_BERTool_0_1, '0']
- [b_mod_constelacion_cb_0_0_0_0, '0', b_BERTool_0_0_0, '0']
- [virtual_source_0, '0', b_BERTool_0, '1']
- [virtual_source_0_0, '0', b_BERTool_0, '2']
- [virtual_source_0_0_0, '0', b_BERTool_0_0, '2']
- [virtual_source_0_0_0_0, '0', b_BERTool_0_0_0, '2']
- [virtual_source_0_0_1, '0', b_BERTool_0_1, '2']
- [virtual_source_0_1, '0', b_BERTool_0_0, '1']
- [virtual_source_0_1_0, '0', b_BERTool_0_1, '1']
- [virtual_source_0_1_0_0, '0', b_BERTool_0_0_0, '1']

metadata:
  file_format: 1
