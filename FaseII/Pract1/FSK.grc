options:
  parameters:
    generate_options: qt_gui
    id: FSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: DF
  id: variable
  parameters:
    value: 4*Rb
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: h
  id: variable
  parameters:
    value: np.array([1]*Sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: DF
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Rb
    type: float
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: P1
    marker1: '0'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: P2
    size: 16*Sps
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: P3
    size: 16*Sps
    srate: samp_rate
    type: float
    ymax: DF
    ymin: '-DF'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: P3
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [b_unipolar2bipolar_ff_0, '0', interp_fir_filter_xxx_0, '0']
- [b_unipolar2bipolar_ff_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
