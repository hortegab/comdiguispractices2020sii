options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ab
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: Channel_BW
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Channel_BW
    orient: Qt.Horizontal
    start: '0.'
    step: (samp_rate/2)/100.
    stop: samp_rate/2.
    value: samp_rate/2.
  states: {}
- name: No_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: No (dB)
    orient: Qt.Horizontal
    start: '-300'
    step: 300/100.
    stop: '0'
    value: '-60'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: Retardo_T3
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,1,1,1
    label: Delay to T3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(impulso)*Sps
    value: '0'
  states: {}
- name: Retardo_T4
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,0,1,1
    label: Delay to T4
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(impulso)*Sps
    value: '0'
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@0:0,0,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: int(Sps/2)
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@1:0,0,1,1
    label: Delay transmited signal to match with the received signal
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: Retardo_Timing+1
  states: {}
- name: Retardo_ojo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center the Eye by a delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: int(Sps/4)
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rect(Sps)
  states: {}
- name: impulso
  id: variable
  parameters:
    value: (0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: E3TRadio_decisor_fb_0
  id: E3TRadio_decisor_fb
  parameters:
    Umbral: '0.'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: b_Canal_AWGN_ff_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: samp_rate
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: Retardo_ojo
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Retardo_Timing
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@0:1,0,1,1
  states: {}
- name: b_Eye_Diagram_simple_f_0
  id: b_Eye_Diagram_simple_f
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '0'
    GrosorLineas: '20'
    N_eyes: '2'
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@0:1,0,1,1
  states: {state: disabled}
- name: b_PSD_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in T3'''
    Ymax: '1e-5'
    gui_hint: menu@2:0,0,1,1
    samp_rate_audio: samp_rate
  states: {state: disabled}
- name: b_PSD_0_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in  R3'''
    Ymax: '1e-5'
    gui_hint: menu@2:1,0,1,1
    samp_rate_audio: samp_rate
  states: {state: disabled}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {}
- name: b_eye_diagram2_f_1
  id: b_eye_diagram2_f
  parameters:
    Delay: Retardo_ojo
    Nvol: '256'
    Sps: Sps
    samp_rate: samp_rate
  states: {state: disabled}
- name: b_eye_diagram_f_0
  id: b_eye_diagram_f
  parameters:
    Delay: Retardo_ojo
    Sps: Sps
    samp_rate: samp_rate
  states: {state: disabled}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: b_unipolar2bipolar_ff_0_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Retardo_bits
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Retardo_T3
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: Retardo_T4
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/hortegab/MisGits/comdiguispractices2020sii/Pract2.Sistema mas basico de com/recibido_super.jpg
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hortegab/MisGits/comdiguispractices2020sii/Pract2.Sistema mas basico de com/enviado.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Eye Diagramm
    label1: T4 versus R4 in time
    label2: PSD
    label3: T3 versus R3
    label4: T4 versus T3 in time
    num_tabs: '5'
  states: {}
- name: note_0
  id: note
  parameters:
    note: SOURCE LAYER
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: PRE-CHANNEL LAYER
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: CHANNEL LAYER
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Mensaje
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Canal
  states: {}
- name: note_0_0_2
  id: note
  parameters:
    note: PCM
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: APPLICATION LAYER
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@1:1,0,1,1
    label1: Info transmitted
    label2: Info Received
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '60'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:0,0,1,1
    label1: Transmitted signal
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:1,0,1,1
    label1: Received Signal
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@2:0,0,1,1
    label1: 'in  T1 '
    label2: in  R1
    marker1: '0'
    marker2: '0'
    name: '"Source Signal"'
    nconnections: '2'
    size: int(64/2)
    srate: Rb/8
    type: float
    width1: '3'
    width2: '3'
    ymax: '128'
    ymin: '-128'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@4:1,0,1,2
    label1: ''
    marker1: '0'
    size: len(impulso)
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    ylabel: input of the waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@4:2,0,1,2
    label1: ''
    size: len(impulso)*Sps
    srate: samp_rate
    style1: '3'
    type: float
    width1: '3'
    ylabel: output of  waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R3b
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {state: disabled}
- name: vso_0_1_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {state: disabled}
- name: vso_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R4
  states: {}
- name: vso_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: vso_0_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_decisor_fb_0, '0', blocks_char_to_float_0, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_decisor_fb_0, '0']
- [E3TRadio_diezma_ff_0, '0', vs_0_0_0, '0']
- [b_Canal_AWGN_ff_0, '0', E3TRadio_diezma_ff_0, '0']
- [b_Canal_AWGN_ff_0, '0', vs_0_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', blocks_float_to_char_0, '0']
- [b_unipolar2bipolar_ff_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [b_unipolar2bipolar_ff_0, '0', vs_0_0_1, '0']
- [b_unipolar2bipolar_ff_0_0, '0', interp_fir_filter_xxx_0, '0']
- [b_unipolar2bipolar_ff_0_0, '0', vs_0_2, '0']
- [blocks_char_to_float_0, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_1, '1']
- [blocks_char_to_float_0_1, '0', blocks_delay_1, '0']
- [blocks_char_to_float_1, '0', b_unipolar2bipolar_ff_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', b_Canal_AWGN_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', vs_0, '0']
- [virtual_source_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_char_to_float_0_1, '0']
- [vso_0_0, '0', b_PSD_0_0, '0']
- [vso_0_1_0, '0', b_PSD_0_0_0, '0']
- [vso_0_1_0_0, '0', b_EYE_Timing_f_0, '0']
- [vso_0_1_0_0, '0', b_Eye_Diagram_simple_f_0, '0']
- [vso_0_1_0_0, '0', b_eye_diagram2_f_1, '0']
- [vso_0_1_0_0, '0', b_eye_diagram_f_0, '0']
- [vso_0_1_0_0_0, '0', blocks_delay_0, '0']
- [vso_0_1_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [vso_0_1_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_1_0_0_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [vso_0_1_0_0_0_2, '0', blocks_delay_0_1_0, '0']
- [vso_0_1_0_0_0_2_0, '0', blocks_delay_0_1, '0']

metadata:
  file_format: 1
