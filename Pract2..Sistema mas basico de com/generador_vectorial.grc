options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '1'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1953125'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: banary random signal
    label1: sinc wave form random signal
    label2: saw random signal
    label3: gaussian white noise
    label4: voice noise
    num_tabs: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: int
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: b_v_aleatoria_scope_f_0
  id: b_v_aleatoria_scope_f
  parameters:
    N_frec: '1024'
    N_time: 20*Sps
    V_p: '1.5'
    gui_hint: Menu@0:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_v_aleatoria_scope_f_0_0
  id: b_v_aleatoria_scope_f
  parameters:
    N_frec: '1024'
    N_time: 20*Sps
    V_p: '1.5'
    gui_hint: Menu@1:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_v_aleatoria_scope_f_0_0_0
  id: b_v_aleatoria_scope_f
  parameters:
    N_frec: '1024'
    N_time: 20*Sps
    V_p: '1.5'
    gui_hint: Menu@2:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_v_aleatoria_scope_f_0_0_1
  id: b_v_aleatoria_scope_f
  parameters:
    N_frec: '1024'
    N_time: 20*Sps
    V_p: '3.'
    gui_hint: Menu@3:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_v_aleatoria_scope_f_0_0_2
  id: b_v_aleatoria_scope_f
  parameters:
    N_frec: '1024'
    N_time: 20*Sps
    V_p: '1.5'
    gui_hint: Menu@4:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: formas
  id: epy_module
  parameters:
    source_code: "import math\nimport numpy as np\n# Cada funcion siguinete es una forma de pulso para una senal digital\n# Los parametros comunmente usados son:\n# Sps (Samples per simbol): Duracion de un simbolo en tiempo discreto\n# ntaps: es el numero de muestras a generar por simbolo. Esto debido a que,\n# en la practica, un simbolo puede invadir a otros simbolos (ISI), asi que\n# las muestras de un simbolo se pueden expandir mas alla de Sps\n\n# Bipolar non return to zero level signal\ndef B_NRZ_L(Sps):\n    return Sps*[1.,]\n##  Forma sinc \ndef sinc(Sps,ntaps):\n    n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)\n    h=np.sinc(n/Sps)\n    return h\n# forma diente se sierra\ndef saw(Sps):\n    return np.linspace(0,Sps-1,Sps)\t\n# Bipolar non return to zero signal\ndef RZ(Sps):\n    h=Sps*[1.,]\n    Sps_m=int(Sps/2)\n    h[Sps_m+1:Sps:1]=np.zeros(Sps-Sps_m)\n    return h\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: formas.sinc(Sps,ntaps)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: formas.RZ(Sps)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: formas.saw(Sps)/Sps
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: s0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: s1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: s2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: s3
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: s4
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: s0
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: s1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: s2
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: s3
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: s4
  states: {}

connections:
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', interp_fir_filter_xxx_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', interp_fir_filter_xxx_0_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', interp_fir_filter_xxx_0_1, '0']
- [analog_noise_source_x_0, '0', virtual_sink_0_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [audio_source_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [blocks_int_to_float_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0_1, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', b_v_aleatoria_scope_f_0, '0']
- [virtual_source_0_0_0, '0', b_v_aleatoria_scope_f_0_0, '0']
- [virtual_source_0_0_0_0, '0', b_v_aleatoria_scope_f_0_0_0, '0']
- [virtual_source_0_0_0_1, '0', b_v_aleatoria_scope_f_0_0_1, '0']
- [virtual_source_0_0_0_2, '0', b_v_aleatoria_scope_f_0_0_2, '0']

metadata:
  file_format: 1
