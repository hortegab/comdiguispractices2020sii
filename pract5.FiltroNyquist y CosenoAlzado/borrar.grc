options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ab
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: Channel_BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Channel_BW
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Channel_BW
    orient: Qt.Horizontal
    start: '0.'
    step: (samp_rate/2)/100.
    stop: samp_rate/2.
    value: BW
  states: {state: disabled}
- name: Nlob
  id: variable
  parameters:
    value: '8'
  states: {}
- name: No_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: No (dB)
    orient: Qt.Horizontal
    start: '-300'
    step: 300/100.
    stop: '0'
    value: '-300'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: Retardo_T3
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,1,1,1
    label: Delay to T3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(impulso)*Sps
    value: '0'
  states: {}
- name: Retardo_T4
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,0,1,1
    label: Delay to T4
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(impulso)*Sps
    value: '0'
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@0:0,0,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@1:0,0,1,1
    label: Delay transmited signal to match with the received signal
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: '7'
  states: {}
- name: Retardo_ojo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center the Eye by a delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: '6'
    widget: counter
  states: {}
- name: Retardo_ojo_t
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Center the Eye-Timing Diagramm
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: int(Sps/4)
    widget: counter
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps, Rolloff)
  states: {}
- name: impulso
  id: variable
  parameters:
    value: (0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,4,-2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Nlob*Sps
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: b_Canal_AWGN_ff_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: samp_rate
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: Retardo_ojo_t
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Retardo_Timing
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@0:1,0,1,1
  states: {}
- name: b_PSD_f_0
  id: b_PSD_f
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in R3'''
    Ymax: '2e-5'
    gui_hint: menu@2:1,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_PSD_f_0_0
  id: b_PSD_f
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in T3'''
    Ymax: '2e-5'
    gui_hint: menu@2:0,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_binary_bipolar_source1_f_0
  id: b_binary_bipolar_source1_f
  parameters:
    Am: '1.'
  states: {}
- name: b_eye_diagram_f_0
  id: b_eye_diagram_f
  parameters:
    Delay: Retardo_ojo
    Sps: Sps
    samp_rate: samp_rate
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Retardo_bits
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Retardo_T3
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: Retardo_T4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: impulso
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: fff
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,3
    label0: Eye Diagramm
    label1: T4 versus R4 in time
    label2: PSD
    label3: T3 versus R3a
    label4: T4 versus T3 in time
    num_tabs: '5'
  states: {}
- name: note_0
  id: note
  parameters:
    note: SOURCE LAYER
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: PRE-CHANNEL LAYER
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: CHANNEL LAYER
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@1:1,0,1,1
    label1: Info transmitted
    label2: Info Received
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '60'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:0,0,1,1
    label1: Transmitted signal
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:1,0,1,1
    label1: Received Signal
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@4:1,0,1,2
    label1: ''
    marker1: '0'
    size: len(impulso)
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    ylabel: input of the waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@4:2,0,1,2
    label1: ''
    size: len(impulso)*Sps
    srate: samp_rate
    style1: '3'
    type: float
    width1: '3'
    ylabel: output of  waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R3b
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_0_2
  id: virtual_sink
  parameters:
    stream_id: R3a
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R3a
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R4
  states: {}
- name: vso_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R3a
  states: {}
- name: vso_0_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: vso_0_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: "import math\nimport numpy\n#######################################################\n##        Hecho por Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n\n#######################################################\n##               Forma rectangular                   ##\n#######################################################                       \ndef rect(Sps):\n    return Sps*[1.,]\n\n#######################################################\n##               Forma de Nyquist                    ##\n#######################################################                       \ndef nyq(Sps,ntaps):\n    n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)\n    h=numpy.sinc(n/Sps)\n#    return h/numpy.amax(h)\n    return h\n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=numpy.amax(h)\n    return h/Amp\n    \n#######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps) # Aqui hay un error, porque esta retornando Nyquist en es de su raiz\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=numpy.amax(h)\n    return h/Amp\n#######################################################\n##            Forma Raiz de Nyquist                  ##\n#######################################################                       \n# En la siguiente funcion hay un error ya que\n# rrcos() no esta calculando bien el caso en que beta==0\ndef rnyq(Sps,ntaps):\n    return rrcos(Sps,ntaps,0) \n\n"
  states: {}

connections:
- [E3TRadio_bipolar_decisor_ff_0, '0', blocks_null_sink_0, '0']
- [E3TRadio_bipolar_decisor_ff_0, '0', vs_0_0_1, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_bipolar_decisor_ff_0, '0']
- [E3TRadio_diezma_ff_0, '0', vs_0_0_0, '0']
- [b_Canal_AWGN_ff_0, '0', interp_fir_filter_xxx_0_0, '0']
- [b_Canal_AWGN_ff_0, '0', vs_0_0, '0']
- [b_binary_bipolar_source1_f_0, '0', interp_fir_filter_xxx_0, '0']
- [b_binary_bipolar_source1_f_0, '0', vs_0_2, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', vs_0_0_2, '0']
- [blocks_vector_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', vs_0_2, '0']
- [interp_fir_filter_xxx_0, '0', b_Canal_AWGN_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', vs_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [vso_0_1_0_0, '0', b_EYE_Timing_f_0, '0']
- [vso_0_1_0_0, '0', b_PSD_f_0, '0']
- [vso_0_1_0_0, '0', b_eye_diagram_f_0, '0']
- [vso_0_1_0_0_0, '0', blocks_delay_0, '0']
- [vso_0_1_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [vso_0_1_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_1_0_0_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [vso_0_1_0_0_0_2, '0', blocks_delay_0_1_0, '0']
- [vso_0_1_0_0_0_2_0, '0', b_PSD_f_0_0, '0']
- [vso_0_1_0_0_0_2_0, '0', blocks_delay_0_1, '0']

metadata:
  file_format: 1
