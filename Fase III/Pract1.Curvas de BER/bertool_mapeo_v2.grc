options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: Constelacion1
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {state: disabled}
- name: Constelacion1
  id: variable
  parameters:
    value: digital.constellation_8psk().points()
  states: {}
- name: Constelacion2
  id: variable
  parameters:
    value: '[(raiz2 + raiz2*1j),  (-raiz2 + raiz2*1j), (-raiz2 - raiz2*1j), (raiz2 - raiz2*1j)]'
  states: {state: disabled}
- name: Constelacion2
  id: variable
  parameters:
    value: '[(1+0j), (raiz2 + raiz2*1j), (0+1j), (-raiz2 + raiz2*1j), (-1+0j), (-raiz2 - raiz2*1j), (0.-1j), (raiz2 - raiz2*1j)]'
  states: {}
- name: Constelacion4
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: EsN0max
  id: variable
  parameters:
    value: '30.'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '-10.'
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mapdirect1
  id: variable
  parameters:
    value: coding.direct_map(Constelacion1)
  states: {}
- name: mapdirect2
  id: variable
  parameters:
    value: coding.direct_map(Constelacion2)
  states: {}
- name: mapinverse1
  id: variable
  parameters:
    value: coding.inverse_map(Constelacion1)
  states: {}
- name: mapinverse2
  id: variable
  parameters:
    value: coding.inverse_map(Constelacion2)
  states: {}
- name: raiz2
  id: variable
  parameters:
    value: 2**(1/2)
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: len(Constelacion2)
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_BERTool_0_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_0_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_1
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_demod_constelacion_cb_0_0_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_demod_constelacion_cb_0_1
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_demod_constelacion_cb_0_1_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion1
  states: {}
- name: b_mod_constelacion_cb_0_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_mod_constelacion_cb_0_0_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion2
  states: {}
- name: b_mod_constelacion_cb_0_0_0_0_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion1
  states: {}
- name: coding
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy\nimport math\n#######################################################\n##        Done by Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n#######################################################\n##       Constellation map  identification           ##\n#######################################################                  \n# Constellation points are analyzed to determine the \n# the map used for ordering of the constellation points\ndef sum_modulus(a,b,modulus):\n    # realiza una suma de a y b en modulo modulus\n    return (a+b)%modulus\n\ndef angle_map(constellation_points):\n    # esta funcion entrega todos los angulos positivos entre 0 y 2pi\n    angles=numpy.angle(constellation_points)\n    return sum_modulus(angles, 2*math.pi, 2*math.pi)\n\ndef inverse_map(constellation_points):\n    M=len(constellation_points)\n    angles=angle_map(constellation_points)\n    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero\n    delta_angle= 2*math.pi/M     # angulo entre puntos\n    cod_inv=numpy.round(angles/delta_angle)\n    cod_inv=cod_inv.astype(numpy.int) #conversion a entero \n    return cod_inv\n\ndef direct_map(constellation_points):\n    M=len(constellation_points)\n    codinv=inverse_map(constellation_points)\n    coddirect=numpy.array([0]*M)\n    for j in range(M):\n        temp=numpy.where(codinv==j)\n        coddirect[j]=temp[0][0]\n    return coddirect\n\n\"\"\" # SECCION DE PRUEBAS DEL CODIGO\nimport gnuradio.digital as digital\nconstelacion=digital.constellation_8psk().points()\nprint(\"constelacion = \", constelacion)\nmapdirect=direct_map(constelacion)\nprint(\"codigo directo = \", mapdirect)\nmapinverse=inverse_map(constelacion)\nprint(\"codigo inverso = \", mapinverse)\n\"\"\"\n\n\n\n\n\n\n"
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: (0,1,3,2,6,7,5,4)
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: (0,1,3,2,7,6,4,5)
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: '"con mapeo"'
    label2: '"sin mapeo"'
    label3: '"con mapeo de gnu"'
    name: '"Curvas de SER"'
    nconnections: '3'
    showports: 'True'
    vlen: N_snr
    width1: '6'
    width2: '6'
    width3: '6'
    x_axis_label: '"Es/N0 [dB]"'
    x_start: EsN0min
    x_step: (EsN0max-EsN0min)/float(N_snr)
    x_units: '"dB"'
    y_axis_label: '"log(Pe)"'
    ymax: '0'
    ymin: '-5'
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX0
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX3
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX0
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: vs0_0_0
  id: virtual_sink
  parameters:
    stream_id: TX0
  states: {}
- name: vs0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX0
  states: {}
- name: vs1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RX3
  states: {}
- name: vs1_1
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}

connections:
- [analog_random_source_x_0_0, '0', b_mod_constelacion_cb_0_0_0, '0']
- [analog_random_source_x_0_0, '0', b_mod_constelacion_cb_0_0_0_0_0, '0']
- [analog_random_source_x_0_0, '0', digital_map_bb_0, '0']
- [analog_random_source_x_0_0, '0', vs0_0_0, '0']
- [analog_random_source_x_0_0, '0', vs0_0_0_0, '0']
- [analog_random_source_x_0_0, '0', vs0_1, '0']
- [b_BERTool_0_0_0, '0', b_demod_constelacion_cb_0_0_0, '0']
- [b_BERTool_0_0_0, '1', qtgui_vector_sink_f_0, '0']
- [b_BERTool_0_0_0_0, '0', b_demod_constelacion_cb_0_1_0, '0']
- [b_BERTool_0_0_0_0, '1', qtgui_vector_sink_f_0, '2']
- [b_BERTool_0_1, '0', b_demod_constelacion_cb_0_1, '0']
- [b_BERTool_0_1, '1', qtgui_vector_sink_f_0, '1']
- [b_demod_constelacion_cb_0_0_0, '0', digital_map_bb_0_0, '0']
- [b_demod_constelacion_cb_0_1, '0', vs1_1, '0']
- [b_demod_constelacion_cb_0_1_0, '0', vs1_0_0_0, '0']
- [b_mod_constelacion_cb_0_0_0, '0', b_BERTool_0_1, '0']
- [b_mod_constelacion_cb_0_0_0_0, '0', b_BERTool_0_0_0, '0']
- [b_mod_constelacion_cb_0_0_0_0_0, '0', b_BERTool_0_0_0_0, '0']
- [digital_map_bb_0, '0', b_mod_constelacion_cb_0_0_0_0, '0']
- [digital_map_bb_0_0, '0', vs1_0_0, '0']
- [virtual_source_0_0_0_0, '0', b_BERTool_0_0_0, '2']
- [virtual_source_0_0_0_0_0, '0', b_BERTool_0_0_0_0, '2']
- [virtual_source_0_0_1, '0', b_BERTool_0_1, '2']
- [virtual_source_0_1_0, '0', b_BERTool_0_1, '1']
- [virtual_source_0_1_0_0, '0', b_BERTool_0_0_0, '1']
- [virtual_source_0_1_0_0_0, '0', b_BERTool_0_0_0_0, '1']

metadata:
  file_format: 1
