options:
  parameters:
    generate_options: qt_gui
    id: FSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: DF
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: Rb
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Sps_f
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: h
  id: variable
  parameters:
    value: np.array([1]*Sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: B
  states: {}
- name: samp_rate_f
  id: variable
  parameters:
    value: samp_rate*Sps_f
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: '0'
    N: Sps
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1.'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/samp_rate
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi*DF
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Es un VCO de tipo complejo con dos entradas:
              Q: para manipular la fase, dada en radianes
              A: Para manipular la maganitud"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_VCO_fase_fc',   # will show up in GRC
                  in_sig=[np.float32,np.float32],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              Q=input_items[0]
              A=input_items[1]
              Sec=output_items[0]
              Sec[:]=A*np.exp(1.j*Q)
              return len(Sec)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: DATOS DADOS
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: DATOS CALCULADOS
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: Vector rotante en P4
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Vector rotante en P5
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: PSD en P4
    label2: PSD en P2
    nconnections: '2'
    type: complex
    width1: '3'
    width2: '3'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate_f
    fc: '0'
    fftsize: '1024'
    label1: PSD en P5
    type: complex
    width1: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: P1
    marker1: '0'
    size: '8'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: P2
    size: 8*Sps
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: P3
    size: 8*Sps
    srate: samp_rate
    type: float
    ymax: math.pi*2*DF/Rb
    ymin: '-math.pi*2*DF/Rb'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: P4.Re
    label2: P4.Im
    size: 8*Sps
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: P5.Re
    label2: P5.Im
    size: 8*Sps*Sps_f
    srate: samp_rate_f
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: Sps_f
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P3
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P4
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P5
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: P1
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: P3
  states: {state: disabled}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: P4
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: P5
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [b_unipolar2bipolar_ff_0, '0', interp_fir_filter_xxx_0, '0']
- [b_unipolar2bipolar_ff_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', E3TRadio_acumulador_truncado_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0_0_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
